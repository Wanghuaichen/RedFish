# Keil uVision project Fish.uvprojx, settings and files
target Fish (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Fish +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   --bin -o  ./Objects/Fish.bin  ./Objects/Fish.axf
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Source/: Delay.c NVIC.c Timer.c UART.c Fish.c CPGCore.c SPI.c Nrf.c IIC.c MPU.c HMC.c DHT11.c GPIO.c FishID.c OnChip.c ADC.c
  group Library
    ./Library/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c startup_stm32f10x_md.s
